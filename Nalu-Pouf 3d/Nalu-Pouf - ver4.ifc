Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Nalu-Pouf - ver4.ifc
Time: 2024-10-24T15:39:03
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (4)
Name
 | Nalu-Pouf_0 - ObjectType: SketchupGroup
 | Nalu-Pouf_1 - ObjectType: SketchupGroup
 | Nalu-Pouf_2 - ObjectType: SketchupGroup
 | Nalu-Pouf_3 - ObjectType: SketchupGroup
